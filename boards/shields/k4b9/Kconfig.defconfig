## boards/shields/k4b9/Kconfig.defconfig
```kconfig
if SHIELD_K4B9

config ZMK_KEYBOARD_NAME
    default "k4b9"

# エンコーダー本体を有効にする
config EC11
    default y

endif
```
